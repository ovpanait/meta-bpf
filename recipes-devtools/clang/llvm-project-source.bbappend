FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\ 
        file://0001-clang-llvm-cmake-Fix-configure-for-packages-using-fi.patch \
	"
